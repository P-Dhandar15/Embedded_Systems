# Keil uVision project RTOS.uvproj, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC2148 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: RTOS +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: ARM7_LPC21xx_KEIL_RVDS KEIL_THUMB_INTERWORK
  c include: C:\Keil_v5\FreeRTOS_V9.0.0rc2\FreeRTOS\Demo\Common\include;C:\Keil_v5\FreeRTOS_V9.0.0rc2\FreeRTOS\Source\portable\RVDS\ARM7_LPC21xx;C:\Keil_v5\FreeRTOS_V9.0.0rc2\FreeRTOS\Source\include;.
  asm include: C:\Keil_v5\FreeRTOS_V9.0.0rc2\FreeRTOS\Source\portable\RVDS\ARM7_LPC21xx
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./: Startup.s list.c queue.c tasks.c port.c portASM.s heap_2.c test_xx.c ADC.h LCD.h task.h GPIO.h EEPROM.h UART.h
